# Keil uVision project Remix.uvproj, settings and files
target Remix (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Remix +hex
  c flags: Optim=1
  c include: ..\lib\CMSIS\CM3\CoreSupport;..\lib\STM32F10x_StdPeriph_Driver\inc;..\kernel;..\app;..\lib\STM32F10x_StdPeriph_Driver\src
  asm include: ..\kernel
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: ..\startup\STM3210E-EVAL.sct
  group kernel
    ../kernel/: remix_core.c remix_cpu.c remix_debug.c remix_list.c remix_queue.c remix_sem.c remix_task.c remix_core_a.asm
  group app
    ../app/: device.c remix_userroot.c stm32f10x_it.c system_stm32f10x.c test.c unoptimize.c
  group lib
    ../lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group startup
    ../startup/: startup_stm32f10x_hd.s
